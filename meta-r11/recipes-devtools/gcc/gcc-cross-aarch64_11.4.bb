TARGET_ARCH = "aarch64"
require recipes-devtools/gcc/gcc-${PV}.inc
require gcc-cross.inc

