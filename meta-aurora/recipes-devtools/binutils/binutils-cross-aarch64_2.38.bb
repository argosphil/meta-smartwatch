TARGET_ARCH = "aarch64"
require binutils.inc
require binutils-${PV}.inc
require binutils-cross.inc
