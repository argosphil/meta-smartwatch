IMAGE_INSTALL:remove:rubyfish = "nfcd"
