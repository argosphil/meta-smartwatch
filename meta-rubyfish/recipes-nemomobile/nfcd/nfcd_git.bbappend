RDEPENDS:${PN}:append:rubyfish = " nfcd-binder-plugin "
